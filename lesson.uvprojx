# Keil uVision project lesson.uvprojx, settings and files
target dbg (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lesson
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: __FPU_PRESENT
  c include: .;..\qpc\3rd_party\CMSIS\Include;..\qpc\3rd_party\ek-tm4c123gxl;.\src;.\src\objects
  asm define: Stack_Size=1024 Heap_Size=0
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --entry Reset_Handler
  group src
    ./src/: bsp.c main.c bsp.h DAC.h DAC.c sound.h sound.c Nokia5110.c Nokia5110.h adc.c adc.h game_engine.h images.c sounds.c systick.h systick.c PLL.h PLL.c game_engine.c timer.c timer.h images.h errors.c
  group ek-tm4c123gxl
    ../qpc/3rd_party/ek-tm4c123gxl/: system_TM4C123GH6PM.c TM4C123GH6PM.h
    ../qpc/3rd_party/ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group objects
    ./src/objects/: enemy.c enemy.h enemy_wave.c enemy_wave.h game_object.c game_object.h missile.c missile.h player.c player.h sprite.c sprite.h object_list.c object_list.h bunker.c bunker.h
